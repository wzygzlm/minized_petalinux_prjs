SRC_URI += "file://user_2017-05-17-14-19-00.cfg \
            file://user_2017-06-25-16-27-00.cfg \
            file://user_2017-06-26-21-37-00.cfg \
            file://user_2018-07-30-18-18-00.cfg \
            file://user_2018-07-31-15-36-00.cfg \
            file://user_2018-07-31-17-44-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

