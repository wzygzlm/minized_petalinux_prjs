IMAGE_INSTALL_append = " peekpoke"
IMAGE_INSTALL_append = " gpio-demo"
IMAGE_INSTALL_append = " i2csensor"
IMAGE_INSTALL_append = " dialog-control"

IMAGE_INSTALL_append = " myapp-init"
IMAGE_INSTALL_append = " myapp"
